## drivers/feas/Kconfig
```kconfig
config FEAS
	tristate "Frame Energy Aware Scheduling"
	help
	  More power saving while meeting performance
```
